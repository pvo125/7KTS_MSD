# Keil uVision project 7KTS_USB.uvproj, settings and files
target 7KTS_USB (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 7KTS_USB +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c include: ..\STM32F10x_StdPeriph_Driver\inc;..\STM32F10x_StdPeriph_Driver\src;..\main;..\MDK_ARM;.\output;..\CMSIS\DeviceSupport\ST\STM32F10x;..\user\SDCARD;..\user\FatFS;..\USB-FS-Device_Driver\inc;..\USB-FS-Device_Driver\src;..\USB-FS-Device_src;..\USB-FS-Device_src\inc;..\user\LCD_Driver;..\user\SPI_SDCARD;..\user\RS232
  memory RVCT4: ROM 0x8000000 size 0x9500
  memory RVCT9: RAM 0x20009500 size 0x4000
  group CMSIS
    ../CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ../CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group main
    ../main/: main.c main.h stm32f10x_it.c
    ../CMSIS/DeviceSupport/ST/STM32F10x/: stm32f10x_conf.h
  group StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c
  group user
    ../user/SPI_SDCARD/: spi_sdcard.c
    ../user/RS232/: RS232.c
  group FatFS
    ../user/FatFS/: ff.c
    ../user/SPI_SDCARD/: diskio.c
    ../user/FatFS/option/: ccsbcs.c
  group USB-FS-Device_Driver
    ../USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB-FS-Device_src
    ../USB-FS-Device_src/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
  group LCD_Driver
    ../user/LCD_Driver/: LCD_Driver.c
